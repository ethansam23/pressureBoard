# Keil uVision project dh_pressureboard_attempt1.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: TLE9854QXW Infineon
  pack: Infineon.TLE985x_DFP.1.2.0
  cpu: IRAM(0x18000000,0x1000) IROM(0x11000000,0x10000) IROM2(0x10FFFFFC,4) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: dh_pressureboard_attempt1
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x11000000 size 0x10000
  memory RVCT5: ROM 0x10fffffc size 0x4
  memory RVCT9: RAM 0x18000000 size 0x1000
  group Source Group 1
    ./app/: main.c scheduler.c status_led.c uart_cmd.c acquisition.c link_frame.c link_tx.c calibration.c fault.c nvm_config.c
software components: CMSIS:CORE 6.2.0, Device:ConfigWizard_v2 2.1.12, Device:SDK:ADC1 0.2.9, Device:SDK:ADC2 0.3.5, Device:SDK:BOOTROM 0.2.5, Device:SDK:CCU6 0.3.1, Device:SDK:GPT12E 0.2.4, Device:SDK:INT 0.3.1, Device:SDK:ISR 0.3.1, Device:SDK:LIN 0.2.5, Device:SDK:PMU 0.2.4, Device:SDK:PORT 0.2.4, Device:SDK:SCU 0.4.2, Device:SDK:TIMER2x 0.2.4, Device:SDK:UART 0.2.6, Device:SDK:WDT1 0.2.5, Device:Startup 1.1.0
